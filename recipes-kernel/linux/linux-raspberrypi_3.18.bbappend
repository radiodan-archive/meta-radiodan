
# Get rid of the raspberries
CMDLINE += "logo.nologo"

KERNEL_MODULE_AUTOLOAD += "snd-bcm2835"
