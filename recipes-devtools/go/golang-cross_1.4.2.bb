
require golang-cross.inc
require golang-common.inc
require golang-${PV}.inc
