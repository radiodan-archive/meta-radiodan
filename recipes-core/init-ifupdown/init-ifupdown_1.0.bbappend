FILESEXTRAPATHS_prepend_raspberrypi := "${THISDIR}/raspberrypi:"
FILESEXTRAPATHS_prepend_raspberrypi2 := "${THISDIR}/raspberrypi:"

